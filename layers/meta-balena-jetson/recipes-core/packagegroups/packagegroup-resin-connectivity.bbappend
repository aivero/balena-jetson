CONNECTIVITY_FIRMWARES_append_jetson-nano = " \
    linux-firmware-iwlwifi-8265 \
    linux-firmware-ibt-12-16 \
"

CONNECTIVITY_FIRMWARES_append_jetson-tx2 = " \
    tegra-firmware-brcm \
    linux-firmware-bcm4354 \
"

CONNECTIVITY_PACKAGES_append_jetson-tx2 = " \
    tegra-brcm-patchram \
    bluez5 \
    bt-scripts \
"
